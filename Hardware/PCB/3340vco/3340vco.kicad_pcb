File: Hardware/PCB/3340vco/3340vco.kicad_pcb (KiCad board)
At the start: 2 copper layers, 214 x 172 mm, 140 parts, among them J1 Conn_02x04_Odd_Even, J10 AudioJack2, J11 AudioJack2, J12 AudioJack2, J13 AudioJack2, J14 AudioJack2, J15 AudioJack2, J16 3_pin_Molex_connector, J17 Conn_01x03, J18 Conn_01x03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

Commit message: Revise headers, silkscreen
Parts:
- removed J17, J21: Conn_01x03, Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical
- removed J18, J22: Conn_01x03, Connector_PinSocket_2.54mm:PinSocket_1x03_P2.54mm_Vertical
- C13, D3, U5: moved to F.Cu
- J19: value Conn_01x03 -> Conn_01x06; footprint Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical -> Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical
- J2: value Conn_01x06 -> Conn_01x09; footprint Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical -> Connector_PinHeader_2.54mm:PinHeader_1x09_P2.54mm_Vertical
- J20: value Conn_01x03 -> Conn_01x06; footprint Connector_PinSocket_2.54mm:PinSocket_1x03_P2.54mm_Vertical -> Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical
- J4: value Conn_01x06 -> Conn_01x09; footprint Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical -> Connector_PinSocket_2.54mm:PinSocket_1x09_P2.54mm_Vertical
- moved J2 15.2 mm to (191.8, 128.3), turned to 180 degrees
- moved J23 15.2 mm to (217.2, 128.3), turned to 180 degrees
- moved J24 15.2 mm to (337.2, 128.3), turned to 0 degrees
- moved J4 15.2 mm to (311.8, 128.3), turned to 0 degrees
- moved J20 10.2 mm to (278.8, 101.6)
- moved J19 10.2 mm to (158.8, 101.6)
- moved J1 9.16 mm to (287.0, 119.4), turned to 0 degrees
- moved U5 5.08 mm to (190.5, 45.7), turned to 270 degrees
- moved C14 2.54 mm to (306.1, 97.8)
- moved C16 2.54 mm to (303.5, 120.7)
- moved C17 2.54 mm to (303.5, 74.9)
- moved R40 2.54 mm to (306.1, 101.6)
- moved R41 2.54 mm to (306.1, 94.0)
- moved R42 2.54 mm to (306.1, 105.4)
- moved R43 2.54 mm to (306.1, 90.2)
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Connections:
- J1 pad 1: GND1 -> LINK_OUT_SAW
- J1 pad 2: LINK_OUT_SAW -> GND1
- J1 pad 3: GND1 -> LINK_OUT_FM_L
- J1 pad 4: LINK_OUT_CV_L -> GND1
- J1 pad 5: GND1 -> LINK_OUT_PW_L
- J1 pad 6: LINK_OUT_PW_L -> GND1
- J1 pad 7: GND1 -> LINK_OUT_CV_L
- J1 pad 8: LINK_OUT_FM_L -> GND1
- J19 pad 1: LINK_OUT_FM -> TRIANGLE_OUT
- J19 pad 2: LINK_OUT_PW -> SAW_OUT
- J19 pad 3: LINK_OUT_CV -> PULSE_OUT
- J2 pad 1: V_OCT -> GND
- J2 pad 2: V_OCT2 -> -12V
- J2 pad 3: LIN_FM_IN -> +12V
- J2 pad 4: SYNC -> PWMIN
- J2 pad 6: PWMIN -> SYNC
- J20 pad 1: LINK_OUT_FM_L -> TRIANGLE_OUT_S
- J20 pad 2: LINK_OUT_PW_L -> SAW_OUT_S
- J20 pad 3: LINK_OUT_CV_L -> PULSE_OUT_S
- J23 pad 2: SIN_R_W -> SIN_A_W
- J23 pad 3: SIN_S_CW -> SIN_R_CCW
- J23 pad 4: SIN_S_W -> SIN_S_CCW
- J23 pad 5: SIN_S_CCW -> SIN_S_W
- J23 pad 6: SIN_R_CCW -> SIN_S_CW
- J23 pad 7: SIN_A_W -> SIN_R_W
- J24 pad 2: SIN_R_W_S -> SIN
- J24 pad 3: SIN_S_CW_S -> SIN_R_CCW_S
- J24 pad 4: SIN_S_W_S -> SIN_S_CCW_S
- J24 pad 5: SIN_S_CCW_S -> SIN_S_W_S
- J24 pad 6: SIN_R_CCW_S -> SIN_S_CW_S
- J24 pad 7: SIN -> SIN_R_W_S
- J4 pad 1: V_OCT_J -> GND1
- J4 pad 2: V_OCT2_J -> -12V_1
- J4 pad 3: LIN_FM_IN_J -> +12V_1
- J4 pad 4: SYNC_J -> PWMIN_J
- J4 pad 6: PWMIN_J -> SYNC_J
Routing:
- net -12V_1: track 51.9 -> 44.0 mm
- net +12V: track 102.6 -> 106.7 mm
- net -12V: track 99.7 -> 102.9 mm
- net +12V_1: track 51.8 -> 49.7 mm
Other:
- board text added: "Back board"
- board text added: "Hero VCO"
- board text added: "Hero VCO front board"
- board text added: "LINK HEADER If you are having trouble connecting a power cable here, that's because this is not a power header. HINT: Count the pins! Power header's over there."
- board text added: "Rich Holmes CC0 1.0 ??/202? https://github.com/holmesrichards/hero"
