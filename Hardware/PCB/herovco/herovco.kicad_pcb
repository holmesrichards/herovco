# Repository holmesrichards/herovco (continued)

## KiCad design Hardware/PCB_back/herovco_back/herovco_back.kicad_pcb

Board: 2 copper layers, 94.0 x 156.0 mm, 58 parts (41 on the bottom side), 38 nets.

Parts:
C201, C202: 100nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C203, C204: 330pF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C205, C206: 10uF; CP_Radial_D5.0mm_P2.00mm
D201, D202: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
GRAF201: Holes; 3340vco_panel_holes
GRAF202: AO logo; analogoutput
GRAF203: CC0 logo; CC0_logo
H201, H202, H203: MountingHole; MountingHole_3.2mm_M3
J201: Conn_01x06; PinSocket_1x06_P2.54mm_Vertical
J202: Conn_01x09; PinSocket_1x09_P2.54mm_Vertical
J203: Conn_01x07; PinSocket_1x07_P2.54mm_Vertical
J204: Conn_02x04_Odd_Even; IDC-Header_2x04_P2.54mm_Vertical
J205, J206, J207, J208, J209, J211, J212, J213, J214, J215: AudioJack2; Jack_6.35mm_PJ_629HAN_slots
J210: Synth_power_2x5; Power_Header
Q201, Q202: 2N3904; TO-92_Inline_Wide
R201: 30k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R202, R207: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R203, R205, R221, R222, R223: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R204: 390R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R206, R211, R213, R214: 18k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R208, R209: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R210: 2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R212: 33k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R215, R216, R217: 24k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R218, R219, R220: 9.1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R224, R225, R226: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U201: TL074; DIP-14_W7.62mm_Socket_LongPads

Connections:
+12V_1: C201.1, C205.1, D201.1, J202.3, R203.1, R205.1, R215.2, R216.2, R217.2, U201.4
-12V_1: C202.2, C206.2, D202.2, J202.2, R206.1, U201.11
/Jacks, power, headers/+12V_IN: D201.2, J210.9, J210.10
/Jacks, power, headers/-12V_IN: D202.1, J210.1, J210.2
CV_IN_J: J202.5, J208.T
GND1: C201.2, C202.1, C205.2, C206.1, J202.1, J203.1, J204.2, J204.4, J204.6, J204.8, J205.S, J206.S, J207.S, J208.S, J209.S, J210.3, J210.4, J210.5, J210.6, J210.7, J210.8, J211.S, J212.S, J213.S, J214.S, J215.S, R202.2, R207.2, R208.2, R213.2, R214.2, R218.2, R219.2, R220.2
LINK_OUT_CV_L: J201.6, J204.7
LINK_OUT_FM_L: J201.4, J204.3
LINK_OUT_PW_L: J201.5, J204.5
LINK_OUT_SAW: C203.1, J204.1, R222.1, R225.2, U201.1
LIN_FM_IN_J: J202.7, J206.T
unnamed: C203.2, R216.1, R219.1, R222.2, U201.2
unnamed: C204.1, R223.1, R226.2, U201.7
unnamed: C204.2, R217.1, R220.1, R223.2, U201.6
unnamed: Q201.3, R203.2, R209.2, U201.13
unnamed: Q202.2, R207.1
unnamed: Q202.3, R205.2, R208.1, U201.12
unnamed: R209.1, R210.2, U201.14
unnamed: R211.1, R213.1, U201.3
unnamed: R212.1, R214.1, U201.5
unnamed: R215.1, R218.1, R221.2, U201.9
PULSE: J213.T, R226.1
PULSE_OUT_S: J201.2, R212.2
PWMIN_J: J202.4, J205.T
SAW: J214.T, R225.1
SAW_OUT_S: J201.3, R211.2
SIN: J203.2, J211.T, R210.1
SIN_R_CCW_S: J203.3, Q201.2, R202.1
SIN_R_W_S: J203.7, R201.1
SIN_S_CCW_S: J203.4, Q201.1, R204.2
SIN_S_CW_S: J203.6, Q202.1, R204.1
SIN_S_W_S: J203.5, R206.2
SYNC_J: J202.6, J207.T
TRI: J212.T, R224.1
TRIANGLE_OUT_S: J201.1, U201.10
TRI_RAW: R201.2, R221.1, R224.2, U201.8
V_OCT2_J: J202.8, J215.T
V_OCT_J: J202.9, J209.T

## KiCad design Hardware/PCB_front/herovco_front/herovco_front.kicad_pcb

Board: 2 copper layers, 94.0 x 125.0 mm, 80 parts (51 on the bottom side), 67 nets.

Parts:
C101, C103, C104, C105, C109, C110: 100nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C102, C107, C108: 10nF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C106: 1nF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C111: 10nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
D101: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D102: 1N4732A; D_DO-41_SOD81_P10.16mm_Horizontal
GRAF101: Holes; herovco_panel_holes
H101, H102, H103: MountingHole; MountingHole_3.2mm_M3
J101: 3_pin_Molex_header; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J102: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J103: Conn_01x09; PinHeader_1x09_P2.54mm_Vertical
J104: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
J105: 3_pin_Molex_connector; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
R101: 3M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R102: 300k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R103: 24k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R104: 5.6k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R105, R106, R107, R108, R111, R118, R119, R124, R126: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R109: 470k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R110, R112, R125, R129: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R113: 1.8k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R114: 1.5M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R115: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R116, R117: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R120: 8.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R121, R122: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R123: 240k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R127: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R128: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R130, R131, R132, R133, R134, R135, R136, R137: 10k 1/8W; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV101, RV103, RV104, RV110, RV111: 100k; Potentiometer_Alpha_RD901F-40-00D_Single_Vertical_centered
RV102, RV107: 10k; Potentiometer_Bourns_3296W_Vertical_screw_centered
RV105: 20k; Potentiometer_Bourns_3296W_Vertical_screw_centered
RV106: 100k; Potentiometer_Bourns_3296W_Vertical_screw_centered
RV108, RV109, RV113: 50k; Potentiometer_Bourns_3296W_Vertical_screw_centered
RV112: 5k; Potentiometer_Bourns_3296W_Vertical_screw_centered
SW101: SW_SPDT_MSM; SPDT-toggle-switch-1M-series
SW102: SW_Rotary12; Rotary_Switch
TP101: TestPoint; TestPoint_Pad_2.5x2.5mm
U101: TL074; DIP-14_W7.62mm_Socket_LongPads
U102: AS3340A; DIP-16_W7.62mm_Socket_LongPads
U103: TL072; DIP-8_W7.62mm_Socket_LongPads
U104: TL431LP; TO-92_Inline_Wide
U105: L79L05_TO92; TO-92_Inline_Wide

Connections:
+8V_REF: J101.2, R102.1, R120.1, R122.2, RV106.3, TP101.1, U104.3
+12V: C103.1, C104.1, C109.1, J103.3, R114.1, R122.1, R127.2, RV110.3, U101.4, U102.16, U103.8
-5V: C101.1, C111.2, D101.1, R104.2, RV102.2, RV102.3, U102.3, U105.3
-12V: C105.2, C110.2, D101.2, J103.2, RV110.1, U101.11, U103.4, U105.2
/CENTER_FREQ: R118.2, RV106.2
/FINE_TUNE: R108.2, RV101.2
/FREQ_CV: R109.2, RV103.2
/HI_FREQ_TRACK: R117.2, RV105.2
/LIN_FM_CV: RV104.2, U101.12
/Octave switch/0V: J105.3, R137.1, SW102.1
/Octave switch/+8V_REF_P: J105.2, R130.2, SW102.9
/Octave switch/OCTAVE_P: J105.1, SW102.13
/PULSE_WIDTH: R123.2, RV110.2
/PWM: R124.2, RV111.2
/VREF: RV107.2, U104.1
CV_IN: J103.5, RV103.3
CV_NODE: R117.1, R118.1, R119.1, U102.15
GND: C101.2, C103.2, C104.2, C105.1, C106.2, C108.2, C109.2, C110.1, C111.1, D102.2, J101.3, J103.1, J104.1, R113.2, R121.2, RV101.1, RV103.1, RV104.1, RV105.1, RV106.1, RV111.1, RV112.1, RV113.1, U101.5, U101.10, U102.12, U103.3, U103.5, U104.2, U105.1
HARD_SYNC: SW101.1, U102.6
HFT: RV105.3, U102.7
LINK_OUT_CV: J102.6, R112.1, R119.2, U101.8
LINK_OUT_FM: C107.2, J102.4, U101.13, U101.14
LINK_OUT_PW: J102.5, R129.1, U103.7
LIN_FM: R114.2, R115.1, R116.1, U102.13
LIN_FM_IN: J103.7, RV104.3
unnamed: C102.1, SW101.2
unnamed: C106.1, U102.11
unnamed: C107.1, R116.2
unnamed: C108.1, R115.2
unnamed: R102.2, RV101.3
unnamed: R103.1, U102.1
unnamed: R103.2, RV102.1
unnamed: R104.1, U102.2
unnamed: R105.1, R106.1, R107.1, R108.1, R109.1, R111.2, U101.6
unnamed: R105.2, U101.1, U101.2
unnamed: R110.1, R112.2, U101.9
unnamed: R110.2, R111.1, U101.7
unnamed: R113.1, U102.14
unnamed: R120.2, RV107.3
unnamed: R121.1, RV107.1
unnamed: R123.1, R124.1, R126.2, U103.2
unnamed: R125.1, R129.2, U103.6
unnamed: R125.2, R126.1, R128.2, U103.1
unnamed: R127.1, R128.1, RV113.3
unnamed: R130.1, R131.2, SW102.8
unnamed: R131.1, R132.2, SW102.7
unnamed: R132.1, R133.2, SW102.6
unnamed: R133.1, R134.2, SW102.5
unnamed: R134.1, R135.2, SW102.4
unnamed: R135.1, R136.2, SW102.3
unnamed: R136.1, R137.2, SW102.2
OCTAVE: J101.1, U101.3
PULSE_OUT: J102.2, R101.1, U102.4
PWMIN: J103.4, RV111.3
PWM_IN: D102.1, R101.2, RV113.2, U102.5
SAW_OUT: J102.3, U102.8
SIN_A_W: J104.2, RV112.2, RV112.3
SIN_R_CCW: J104.3, RV108.1
SIN_R_W: J104.7, RV108.2, RV108.3
SIN_S_CCW: J104.4, RV109.1
SIN_S_CW: J104.6, RV109.3
SIN_S_W: J104.5, RV109.2
SOFT_SYNC: SW101.3, U102.9
SYNC: C102.2, J103.6
TRIANGLE_OUT: J102.1, U102.10
V_OCT: J103.9, R106.2
V_OCT2: J103.8, R107.2

## KiCad design Hardware/PCB/3340vco/3340vco.kicad_pcb

Board: 2 copper layers, 214.0 x 172.0 mm, 136 parts (87 on the bottom side), 105 nets.

Parts:
C1: 100nF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C2, C5, C8: 10nF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C3, C6, C7, C9, C10, C14, C15: 100nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C4: 1nF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C11, C12: 10uF; CP_Radial_D5.0mm_P2.00mm
C13: 1uF; CP_Radial_D5.0mm_P2.00mm
C16, C17: 180pF; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1, D2: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
D3: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D6: 1N4732A; D_DO-41_SOD81_P10.16mm_Horizontal
GRAF1, GRAF2: Holes; 3340vco_panel_holes
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_3.2mm_M3
J1: Conn_02x04_Odd_Even; IDC-Header_2x04_P2.54mm_Vertical
J2: Conn_01x09; PinHeader_1x09_P2.54mm_Vertical
J3: 3_pin_Molex_header; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J4: Conn_01x09; PinSocket_1x09_P2.54mm_Vertical
J5: Synth_power_2x5; Power_Header
J6, J7, J8, J9, J10, J11, J12, J13, J14, J15: AudioJack2; Jack_6.35mm_PJ_629HAN_slots
J16: 3_pin_Molex_connector; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J19: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J20: Conn_01x06; PinSocket_1x06_P2.54mm_Vertical
J23: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
J24: Conn_01x07; PinSocket_1x07_P2.54mm_Vertical
Q1, Q2: 2N3904; TO-92_Inline_Wide
R1: 3M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 24k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 5.6k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R5, R6, R8, R10, R16, R17, R22, R24: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7: 470k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R11, R18, R25, R37, R59: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R12: 1.8k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R13: 1.5M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R14: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R15, R23: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R19: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R20, R62, R63: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R21: 240k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R26, R53, R54, R55, R58: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R27, R28, R29, R30, R31, R32, R33, R34: 10k 1/8W; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R35: 30k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R36, R61: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R38: 390R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R39: 2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R40, R42, R43, R50, R51, R52, R60: 18k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R41: 33k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R44, R45, R46: 43k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R47, R48, R49: 16k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R56: 300k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R57: 8.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1, RV10: 10k; Potentiometer_Bourns_3296W_Vertical_screw_centered
RV2, RV3, RV7, RV8, RV9: 100k; Potentiometer_Alpha_RD901F-40-00D_Single_Vertical_centered
RV4, RV11, RV13: 50k; Potentiometer_Bourns_3296W_Vertical_screw_centered
RV5: 20k; Potentiometer_Bourns_3296W_Vertical_screw_centered
RV6: 100k; Potentiometer_Bourns_3296W_Vertical_screw_centered
RV12: 5k; Potentiometer_Bourns_3296W_Vertical_screw_centered
SW1: SW_SPDT_MSM; SPDT-toggle-switch-1M-series
SW2: SW_Rotary12; Rotary_Switch
TP1: TestPoint; TestPoint_Pad_2.5x2.5mm
U1, U6: TL074; DIP-14_W7.62mm_Socket_LongPads
U2: AS3340A; DIP-16_W7.62mm_Socket_LongPads
U3: TL072; DIP-8_W7.62mm_Socket_LongPads
U4: TL431LP; TO-92_Inline_Wide
U5: L79L05_TO92; TO-92_Inline_Wide

Connections:
+8V_REF: J3.2, R26.1, R56.1, R57.2, RV6.3, TP1.1, U4.3
+12V: C3.1, C6.1, C9.1, J2.3, R13.1, R19.2, R26.2, RV8.3, U1.4, U2.16, U3.8
+12V_1: C11.1, C14.1, D1.1, J4.3, R37.1, R44.2, R45.2, R46.2, R59.1, U6.4
-5V: C1.1, C13.2, D3.1, R3.2, RV1.2, RV1.3, U2.3, U5.3
-12V: C7.2, C10.2, D3.2, J2.2, RV8.1, U1.11, U3.4, U5.2
-12V_1: C12.2, C15.2, D2.2, J4.2, R60.1, U6.11
/CENTER_FREQ: R16.2, RV6.2
/FINE_TUNE: R6.2, RV2.2
/FREQ_CV: R7.2, RV3.2
/HI_FREQ_TRACK: R15.2, RV5.2
/LIN_FM_CV: RV7.2, U1.12
/PULSE_WIDTH: R21.2, RV8.2
/PWM: R22.2, RV9.2
/Panel components and power/0V: J16.3, R34.1, SW2.1
/Panel components and power/+8V_REF_P: J16.2, R27.2, SW2.9
/Panel components and power/+12V_IN: D1.2, J5.9, J5.10
/Panel components and power/-12V_IN: D2.1, J5.1, J5.2
/Panel components and power/OCTAVE_P: J16.1, SW2.13
/Panel components and power/VREF: RV10.2, U4.1
CV_IN: J2.5, RV3.3
CV_IN_J: J4.5, J9.T
CV_NODE: R15.1, R16.1, R17.1, U2.15
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.1, C9.2, C10.1, C13.1, D6.2, J2.1, J3.3, J23.1, R12.2, R58.1, RV2.1, RV3.1, RV5.1, RV6.1, RV7.1, RV9.1, RV12.1, RV13.1, U1.5, U1.10, U2.12, U3.3, U3.5, U4.2, U5.1
GND1: C11.2, C12.1, C14.2, C15.1, J1.2, J1.4, J1.6, J1.8, J4.1, J5.3, J5.4, J5.5, J5.6, J5.7, J5.8, J6.S, J7.S, J8.S, J9.S, J10.S, J11.S, J12.S, J13.S, J14.S, J15.S, J24.1, R36.2, R42.2, R43.2, R47.2, R48.2, R49.2, R61.2, R62.2
HARD_SYNC: SW1.1, U2.6
HFT: RV5.3, U2.7
LINK_OUT_CV: J19.6, R11.1, R17.2, U1.8
LINK_OUT_CV_L: J1.7, J20.6
LINK_OUT_FM: C8.2, J19.4, U1.13, U1.14
LINK_OUT_FM_L: J1.3, J20.4
LINK_OUT_PW: J19.5, R25.1, U3.7
LINK_OUT_PW_L: J1.5, J20.5
LINK_OUT_SAW: C16.1, J1.1, R51.1, R54.2, U6.1
LIN_FM: R13.2, R14.1, R23.1, U2.13
LIN_FM_IN: J2.7, RV7.3
LIN_FM_IN_J: J4.7, J7.T
unnamed: C2.1, SW1.2
unnamed: C4.1, U2.11
unnamed: C5.1, R14.2
unnamed: C8.1, R23.2
unnamed: C16.2, R45.1, R48.1, R51.2, U6.2
unnamed: C17.1, R52.1, R55.2, U6.7
unnamed: C17.2, R46.1, R49.1, R52.2, U6.6
unnamed: Q1.3, R37.2, R63.2, U6.13
unnamed: Q2.2, R61.1
unnamed: Q2.3, R59.2, R62.1, U6.12
unnamed: R2.1, U2.1
unnamed: R2.2, RV1.1
unnamed: R3.1, U2.2
unnamed: R4.2, U1.1, U1.2
unnamed: R9.2, R10.1, U1.7
unnamed: R4.1, R5.1, R6.1, R7.1, R8.1, R10.2, U1.6
unnamed: R9.1, R11.2, U1.9
unnamed: R12.1, U2.14
unnamed: R18.1, R25.2, U3.6
unnamed: R18.2, R20.2, R24.1, U3.1
unnamed: R19.1, R20.1, RV13.3
unnamed: R21.1, R22.1, R24.2, U3.2
unnamed: R27.1, R28.2, SW2.8
unnamed: R28.1, R29.2, SW2.7
unnamed: R29.1, R30.2, SW2.6
unnamed: R30.1, R31.2, SW2.5
unnamed: R31.1, R32.2, SW2.4
unnamed: R32.1, R33.2, SW2.3
unnamed: R33.1, R34.2, SW2.2
unnamed: R39.2, R63.1, U6.14
unnamed: R40.1, R42.1, U6.3
unnamed: R41.1, R43.1, U6.5
unnamed: R44.1, R47.1, R50.2, U6.9
unnamed: R56.2, RV2.3
unnamed: R57.1, RV10.3
unnamed: R58.2, RV10.1
OCTAVE: J3.1, U1.3
PULSE: J13.T, R55.1
PULSE_OUT: J19.3, R1.1, U2.4
PULSE_OUT_S: J20.3, R41.2
PWMIN: J2.4, RV9.3
PWMIN_J: J4.4, J6.T
PWM_IN: D6.1, R1.2, RV13.2, U2.5
SAW: J14.T, R54.1
SAW_OUT: J19.2, U2.8
SAW_OUT_S: J20.2, R40.2
SIN: J11.T, J24.2, R39.1
SIN_A_W: J23.2, RV12.2, RV12.3
SIN_R_CCW: J23.3, RV11.1
SIN_R_CCW_S: J24.3, Q1.2, R36.1
SIN_R_W: J23.7, RV11.2, RV11.3
SIN_R_W_S: J24.7, R35.1
SIN_S_CCW: J23.4, RV4.1
SIN_S_CCW_S: J24.4, Q1.1, R38.2
SIN_S_CW: J23.6, RV4.3
SIN_S_CW_S: J24.6, Q2.1, R38.1
SIN_S_W: J23.5, RV4.2
SIN_S_W_S: J24.5, R60.2
SOFT_SYNC: SW1.3, U2.9
SYNC: C2.2, J2.6
SYNC_J: J4.6, J8.T
TRI: J12.T, R53.1
TRIANGLE_OUT: J19.1, U2.10
TRIANGLE_OUT_S: J20.1, U6.10
TRI_RAW: R35.2, R50.1, R53.2, U6.8
V_OCT: J2.9, R5.2
V_OCT2: J2.8, R8.2
V_OCT2_J: J4.8, J15.T
V_OCT_J: J4.9, J10.T

## KiCad design Hardware/PCB/3340breadboard/3340breadboard.kicad_pcb

Board: 2 copper layers, 7 parts (0 on the bottom side), 5 nets, no tracks yet.

Parts:
C1, C2: 10uF; CP_Radial_D5.0mm_P2.00mm
C3, C4: 0.1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1, D2: 1N5817; D_DO-41_SOD81_P7.62mm_Horizontal
J1: Synth_power_2x5; Power_Header

Connections:
+12V: C1.1, C3.1, D1.1
-12V: C2.2, C4.2, D2.2
/+12_IN: D1.2, J1.9, J1.10
/-12_IN: D2.1, J1.1, J1.2
GND: C1.2, C2.1, C3.2, C4.1, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8

## Commit log

2021-05-01 Initial version
2021-05-07 Update README, some schem/pcb adjustments
2021-05-30 Catch up various updates
2021-08-07 Kosmo_panel lib update
2021-09-13 Cleanup
2021-09-15 panel revision
2021-09-15 SVG decontamination
2021-09-18 Image location
2021-09-30 Trimmer tweak position
2021-09-30 AS3340A notes
2021-09-30 Ignore breadboarding directory
2021-09-30 Add link, other schem tweaks
2021-09-30 Link corrections
2021-10-01 Redesign PWM section for good link setup
2021-10-02 Some schematics tweaks, schem PDF
2021-10-02 More schematics tweaks
2021-10-02 sch and README tweaks, BOM
2021-10-03 Fix brain dead op amp topology, and improve voltage reference and its use
2021-10-03 Put that resistor back
2021-10-03 Preliminary board division and layout
2021-10-04 More layout work
2021-10-05 Replace tri to sine, more layout
2021-10-06 ignore test
2021-10-08 Fix label
2021-10-24 Ignore test stuff
2021-10-26 Update annotations
2021-10-27 Revise power ports
2021-10-27 Revise headers, silkscreen
2021-10-27 Rename and break PCBs out to separate projects
2021-10-28 BOMs, resistor symbol normalization
2021-10-30 Revised output stage values
2021-10-30 Revise annotation
2021-11-01 Change regulator output cap and rearrange
2021-11-01 First routing
2021-11-01 Panel in KiCad
2021-11-02 Rear panel labels
2021-11-02 PCB labels
2021-11-17 Change of plan, both boards in one project (but never again)
2021-11-18 Test points
2021-11-25 rm cruft
2021-12-10 Version 6 (PCB)
2021-12-10 Change pot symbols and fix orientation, other small tweaks
2021-12-22 Pre-breadboard updates
2022-01-17 rm Zener, change adj ref to fixed and modify octave switch and fine tune accordingly
2022-01-17 rm Zener, change adj ref to fixed, cont'd
2022-01-18 Panel updates; reannotate; correct PCB errors
2022-01-18 Sync input revision
2022-01-19 Big panel and PCB revisions
2022-01-19 Sch cleanup, switch footprint
2022-01-19 rm superfluous header pin
2022-01-21 Different sync switch, other tweaks
2022-01-26 Sine trimmers to back board, misc accumulated tweaks
2022-01-29 Schematics tweaks, silk and fab cleanup, layout PDFs, panel revisions
2022-01-29 Panel revision, Gerbers
2022-01-30 Fix switch PCB
2022-01-30 100k in octave switch; rotary footprint; note stuff to fix
2022-02-01 schem tweaks
2022-02-02 README update
2022-02-04 BUILD.md
2022-03-06 Initial BOM; DNF the test points; README typo
2022-03-06 Convert jack footprints to slotted; clean up silkscreen; add silkscreen notes to match resistors
2022-03-06 Correct slide switch footprint; use TO-92 wide for regulator
2022-03-06 5 mm pitch for 330 pF
2022-03-06 Resistors between trimmers to other side of front board
2022-03-07 New schematic PDF
2022-03-08 10k resistors in octave switch
2022-03-08 10k resistors in octave switch (build doc)
2022-03-09 Use uninverted PW CV
2022-03-09 Revert "Use uninverted PW CV"
    This reverts commit afeb33e5ee15cb89f0e577c33928166723912ed3.
2022-03-09 Note on PW CV
2022-06-19 Post prototype updates
2022-06-19 Libraries, redo gerbers
2022-06-19 License
2022-06-19 Back photo
2022-06-20 Blog post link
2022-06-22 Note on CEM vs AS
2022-06-23 Add howitworks
2022-06-23 howitworks link in README
2022-06-24 20k trimmers to 10k
2022-06-24 PCB/gerber_gen.sh
