File: Hardware/PCB/herovco/herovco.kicad_sch (KiCad schematic)
At the start: 13 parts, among them J1 Conn_01x09, J10 Conn_01x03, J11 3_pin_Molex_connector, J12 4_pin_Molex_connector, J13 Conn_02x04_Odd_Even, J2 Conn_01x07, J3 Conn_01x03, J4 Conn_01x03, J5 3_pin_Molex_header, J6 4_pin_Molex_header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

Commit message: rm superfluous header pin
Parts:
- J2: value Conn_01x07 -> Conn_01x06; footprint Connector_PinHeader_2.54mm:PinHeader_1x07_P2.54mm_Vertical -> Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical; symbol Connector_Generic:Conn_01x07 -> Connector_Generic:Conn_01x06
- J8: value Conn_01x07 -> Conn_01x06; footprint Connector_PinSocket_2.54mm:PinSocket_1x07_P2.54mm_Vertical -> Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical; symbol Connector_Generic:Conn_01x07 -> Connector_Generic:Conn_01x06
Connections:
- net Front PCB/SIN_A_W: now also J2.1 (Pin_1); no longer J2.2 (Pin_2)
- net Front PCB/SIN_R_CCW: now also J2.2 (Pin_2); no longer J2.3 (Pin_3)
- net Front PCB/SIN_R_W: now also J2.6 (Pin_6); no longer J2.7 (Pin_7)
- net Front PCB/SIN_S_CCW: now also J2.3 (Pin_3); no longer J2.4 (Pin_4)
- net Front PCB/SIN_S_CW: now also J2.5 (Pin_5); no longer J2.6 (Pin_6)
- net Front PCB/SIN_S_W: now also J2.4 (Pin_4); no longer J2.5 (Pin_5)
- net GND: no longer J2.1 (Pin_1)
- net GND1: no longer J8.1 (Pin_1)
- net Jacks, power, etc/SIN: now also J8.1 (Pin_1); no longer J8.2 (Pin_2)
- net Outputs and sin/SIN_R_CCW_S: now also J8.2 (Pin_2); no longer J8.3 (Pin_3)
- net Outputs and sin/SIN_R_W_S: now also J8.6 (Pin_6); no longer J8.7 (Pin_7)
- net Outputs and sin/SIN_S_CCW_S: now also J8.3 (Pin_3); no longer J8.4 (Pin_4)
- net Outputs and sin/SIN_S_CW_S: now also J8.5 (Pin_5); no longer J8.6 (Pin_6)
- net Outputs and sin/SIN_S_W_S: now also J8.4 (Pin_4); no longer J8.5 (Pin_5)
Changed lines of the file:
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@@
   (junction (at 232.41 91.44) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 107.95 81.28) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 107.95 73.66) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 232.41 93.98) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 143.51 73.66) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 157.48 83.82) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 147.32 74.93) (xy 147.32 73.66))
+  (wire (pts (xy 143.51 48.26) (xy 143.51 74.93))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 143.51 48.26) (xy 143.51 73.66))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 160.02 58.42) (xy 142.24 58.42))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 143.51 73.66) (xy 143.51 81.28))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
-  (wire (pts (xy 107.95 81.28) (xy 107.95 137.16))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 95.25 116.84) (xy 109.22 116.84))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 107.95 81.28) (xy 109.22 81.28))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 142.24 158.75) (xy 160.02 158.75))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 147.32 73.66) (xy 143.51 73.66))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 109.22 137.16) (xy 107.95 137.16))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 142.24 81.28) (xy 143.51 81.28))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 142.24 156.21) (xy 160.02 156.21))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 107.95 73.66) (xy 107.95 81.28))
+  (wire (pts (xy 107.95 73.66) (xy 107.95 137.16))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (pin "3")
   )
-  (symbol (lib_id "Connector_Generic:Conn_01x07") (at 114.3 88.9 0) (unit 1)
+  (symbol (lib_id "Connector_Generic:Conn_01x06") (at 114.3 88.9 0) (unit 1)
     (in_bom yes) (on_board yes)
     (property "Reference" "J2" (id 0) (at 119.38 88.9 90))
-    (property "Value" "Conn_01x07" (id 1) (at 116.84 88.9 90))
-    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x07_P2.54mm_Vertical" (id 2) (at 114.3 88.9 0)
+    (property "Value" "Conn_01x06" (id 1) (at 116.84 90.17 90))
+    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical" (id 2) (at 114.3 88.9 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "5")
     (pin "6")
-    (pin "7")
   )
   (symbol (lib_id "Connector_Generic:Conn_01x09") (at 114.3 58.42 0) (unit 1)
@@
     (pin "1")
   )
-  (symbol (lib_id "Connector_Generic:Conn_01x07") (at 137.16 88.9 0) (mirror y) (unit 1)
+  (symbol (lib_id "Connector_Generic:Conn_01x06") (at 137.16 88.9 0) (mirror y) (unit 1)
     (in_bom yes) (on_board yes)
     (property "Reference" "J8" (id 0) (at 132.08 88.9 90))
-    (property "Value" "Conn_01x07" (id 1) (at 134.62 88.9 90))
-    (property "Footprint" "Connector_PinSocket_2.54mm:PinSocket_1x07_P2.54mm_Vertical" (id 2) (at 137.16 88.9 0)
+    (property "Value" "Conn_01x06" (id 1) (at 134.62 90.17 90))
+    (property "Footprint" "Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical" (id 2) (at 137.16 88.9 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "5")
     (pin "6")
-    (pin "7")
   )
   (symbol (lib_id "ao_symbols:3_pin_Molex_connector") (at 137.16 139.7 0) (mirror y) (unit 1)
@@
     (pin "3")
   )
-  (symbol (lib_id "power:GND1") (at 147.32 74.93 0) (mirror y) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR05" (id 0) (at 147.32 81.28 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND1" (id 1) (at 147.193 79.3242 0))
-    (property "Footprint" "" (id 2) (at 147.32 74.93 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 147.32 74.93 0)
+  (symbol (lib_id "power:GND1") (at 143.51 74.93 0) (mirror y) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "#PWR05" (id 0) (at 143.51 81.28 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND1" (id 1) (at 143.383 79.3242 0))
+    (property "Footprint" "" (id 2) (at 143.51 74.93 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 143.51 74.93 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (sheet (at 160.02 78.74) (size 38.1 38.1) (fields_autoplaced)
+  (sheet (at 160.02 81.28) (size 38.1 35.56) (fields_autoplaced)
     (stroke (width 0) (type solid) (color 0 0 0 0))
     (fill (color 0 0 0 0.0000))
-    (property "Sheet name" "Outputs and sin" (id 0) (at 160.02 78.0284 0)
+    (property "Sheet name" "Outputs and sin" (id 0) (at 160.02 80.5684 0)
       (effects (font (size 1.27 1.27)) (justify left bottom))
     )
@@
     )
     (path "/00000000-0000-0000-0000-00006196071f"
-      (reference "J2") (unit 1) (value "Conn_01x07") (footprint "Connector_PinHeader_2.54mm:PinHeader_1x07_P2.54mm_Vertical")
+      (reference "J2") (unit 1) (value "Conn_01x06") (footprint "Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical")
     )
     (path "/e858366f-5495-4a43-abd9-13c2a6aa2f32"
@@
     )
     (path "/00000000-0000-0000-0000-000061a09f7f"
-      (reference "J8") (unit 1) (value "Conn_01x07") (footprint "Connector_PinSocket_2.54mm:PinSocket_1x07_P2.54mm_Vertical")
+      (reference "J8") (unit 1) (value "Conn_01x06") (footprint "Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical")
     )
     (path "/92b24e2f-4bfa-4231-87b9-3b5728a9e244"

Commit message: Different sync switch, other tweaks
Parts:
- removed J12: 4_pin_Molex_connector, Connector_Molex:Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x04
- removed J6: 4_pin_Molex_header, Connector_Molex:Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x04
- added J15, J6: Wire pads, Connector_Wire:SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm, symbol Connector_Generic:Conn_01x01
- added J16, J17, J18, J7, J8, J9: Conn_01x01, herovco:SolderWire-round_1x01_D0.9mm_OD2.1mm, symbol Connector_Generic:Conn_01x01
- renumbered J7 to J10, J8 to J11, J9 to J12, J10 to J13, J11 to J14, J13 to J19
Connections:
- net Front PCB/HARD_SYNCA: now also J9.1 (Pin_1)
- net Front PCB/SOFT_SYNCA: now also J7.1 (Pin_1)
- net Front PCB/SOFT_SYNC_OFF: now also J8.1 (Pin_1)
- net Front PCB/SYNCA: now also J6.1 (Pin_1)
- net Octave and sync switches/HARD_SYNCA_P: now also J18.1 (Pin_1)
- net Octave and sync switches/SOFT_SYNCA_P: now also J16.1 (Pin_1)
- net Octave and sync switches/SOFT_SYNC_OFF_P: now also J17.1 (Pin_1)
- net Octave and sync switches/SYNCA_P: now also J15.1 (Pin_1)

Commit message: Sine trimmers to back board, misc accumulated tweaks
Parts:
- removed J11: Conn_01x06, Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x06
- removed J2: Conn_01x06, Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x06
Connections:
- net LINK_OUT_CV_L renamed LINK_OUT_CV_B
- net LINK_OUT_FM_L renamed LINK_OUT_FM_B
- net LINK_OUT_PW_L renamed LINK_OUT_PW_B
Other:
- sheet Front PCB ports: added none; removed SIN_A_W, SIN_R_CCW, SIN_R_W, SIN_S_CCW, SIN_S_CW, SIN_S_W
- sheet Outputs and sin ports: added none; removed SIN_R_CCW_S, SIN_R_W_S, SIN_S_CCW_S, SIN_S_CW_S, SIN_S_W_S
- moved on the sheet: J12, J13, J14, J15, J16, J17, J18, J3, J4, J5, J6, J7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

Commit message: Schematics tweaks, silk and fab cleanup, layout PDFs, panel revisions
Parts:
- renumbered J12 to J10, J13 to J11, J14 to J12, J15 to J13, J16 to J14, J17 to J15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
Connections:
- net GND: no longer J4.1 (Pin_1)
- net Front PCB/+10V_REF renamed Front PCB/-5V_REF
- net Octave and sync switches/+10V_REF_P renamed Octave and sync switches/-5V_REF_P
- net Octave and sync switches/0V renamed Octave and sync switches/+5V_REF_P
- new net Front PCB/+5V_REF: J4.1 (Pin_1)
Other:
- sheet Front PCB ports: added +5V_REF, -5V_REF; removed +10V_REF
- sheet Octave and sync switches ports: added +5V_REF_P, -5V_REF_P; removed +10V_REF_P, 0V
