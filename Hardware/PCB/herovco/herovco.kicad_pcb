# Repository holmesrichards/herovco

File README.md:

# Hero VCO

The Hero VCO is a 3340 based voltage controlled oscillator synth module in Kosmo format. Notable features of the Hero include:

* Triangle, ramp, pulse, and sine waveforms with separate output jacks.
* Uniform, zero-centered ±5 Vpp output amplitudes for the various wave shapes.
* Input jacks for two V/oct CVs, as well as PWM, linear FM, and exponential FM (pitch) CVs with attenuators.
* Separate initial pulse width and PWM attenuator knobs.
* Wide pulse width range.
* Switch selectable hard, soft, or no sync.
* 11 position octave switch plus fine tuning knob.
* Front panel access to trimmers for calibration of V/oct tracking, center pitch, and pulse width range limit.
* Entirely through hole construction with readily available components.

Two well known problems with the 3340 in its datasheet configuration are addressed:

* Regulated -5 V supply improves stability and suppresses pulse width frequency shift.
* Falling edge oscillations on pulse wave shape are eliminated.

But perhaps the most significant feature of the design is the link header. This may be used to connect the Hero to one or more of its sister module, the [Sidekick VCO](https://github.com/holmesrichards/sidekickvco), in a modern riff on the classic Moog 921a/921b system. The Sidekick is half the width of the Hero and lacks some of the Hero's front panel controls and inputs, but internally is essentially the same circuit as the Hero. Via the link, the Sidekicks receive summed V/oct pitch CV, linear FM CV, and pulse width CV from the Hero, based on its front panel controls and inputs. In this way a common set of control voltages is presented to the Hero and all its Sidekicks. The link also permits the Sidekicks to be hard or soft synced to the Hero. This allows easy configuration of a multi-oscillator synth voice in a relatively compact system.

The Hero design specifies and assumes the Alfa AS3340A VCO chip, an improvement to the AS3340, although the AS3340 or Curtis CEM3340 probably would work. (See build notes.)

Thanks for inspiration to several other VCOs: the [Kassutronics VCO 3340](https://kassu2000.blogspot.com/2018/06/vco-3340.html), the [LMNC 1222 Performance VCO](https://www.lookmumnocomputer.com/1222-performance-vco), and the [Thomas Henry VCO Maximus](https://www.birthofasynth.com/Thomas_Henry/Pages/VCO_Maximus-Detail.html).

## Project status

One prototype (v. 0.91) has been built and it works. There were some minor issues identified:

- L79L05 footprint does not have wide leg spacing.
- Jack footprints are round holes instead of slots.
- 330pF cap footprint is 2.5 mm pitch, should be 5 mm.
- Resistors specified for octave switch are 100k, 10k would be (arguably) better.
- No indication on silkscreen for which resistors to match.
- Some silkscreen refs obscured by pads.
- Resistors between trimmers make assembly awkward, move to other side of board.
- Slide switch footprint incorrect, requires cutting off mounting legs.

See build notes for mitigations. These issues have been corrected in the design files but the revised version has not been tested. 

## Width

10 cm.

## Current draw
33 mA +12 V, 34 mA -12 V.

## Photos

## Documentation

* [Schematic](Docs/herovco.pdf)
* PCB layout: [front](Docs/herovco_layout_front.pdf), [back](Docs/herovco_layout_back.pdf)
* [BOM](Docs/herovco_bom.md)
* [Build notes](Docs/build.md)
* [How it works](Docs/howitworks.md)
* [Blog post](https://analogoutputblog.wordpress.com/2022/06/20/hero-and-sidekick/)

## GitHub repository

* [https://github.com/holmesrichards/herovco](https://github.com/holmesrichards/herovco)

## Submodules

This repo uses submodules aoKicad and Kosmo_panel, which provide needed libaries for KiCad. To clone:

```
git clone git@github.com:holmesrichards/herovco.git
git submodule init
git submodule update
```

Alternatively do

```
git clone --recurse-submodules git@github.com:holmesrichards/herovco.git
```

Or if you download the repository as a zip file, you must also click on the "aoKicad" and "Kosmo\_panel" links on the GitHub page (they'll have "@ something" after them) and download them as separate zip files which you can unzip into this repo's aoKicad and Kosmo\_panel directories.

If desired, copy the files from aoKicad and Kosmo\_panel to wherever you prefer (your KiCad user library directory, for instance, if you have one). Then in KiCad, go into Edit Symbols and add symbol libraries 

```
aoKicad/ao_symbols
Kosmo_panel/Kosmo
```
and go into Edit Footprints and add footprint libraries 
```
aoKicad/ao_tht
Kosmo_panel/Kosmo_panel.
```

## KiCad design Hardware/PCB/herovco/herovco.kicad_pcb

Parts:
J1: Conn_01x09; PinHeader_1x09_P2.54mm_Vertical
J2, J3: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J4: 3_pin_Molex_header; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J5, J13: Wire pads; SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm
J6, J7, J8, J14, J15, J16: Conn_01x01; SolderWire-round_1x01_D0.9mm_OD2.1mm
J9: Conn_01x09; PinSocket_1x09_P2.54mm_Vertical
J10, J11: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical
J12: 3_pin_Molex_connector; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J17: Conn_02x04_Odd_Even; IDC-Header_2x04_P2.54mm_Vertical

Connections:
+12V: J1.3; also elsewhere on the board
+12V_1: J9.3; also elsewhere on the board
-12V: J1.2; also elsewhere on the board
-12V_1: J9.2; also elsewhere on the board
/Front PCB/+5V_REF: J4.1; also elsewhere on the board
/Front PCB/-5V_REF: J4.3; also elsewhere on the board
/Front PCB/CV_IN: J1.5; also elsewhere on the board
/Front PCB/CV_SUM: J3.3; also elsewhere on the board
/Front PCB/HARD_SYNCA: J8.1; also elsewhere on the board
/Front PCB/LINK_OUT_FM: J3.1; also elsewhere on the board
/Front PCB/LINK_OUT_PW: J3.2; also elsewhere on the board
/Front PCB/LIN_FM_IN: J1.7; also elsewhere on the board
/Front PCB/OCTAVE: J4.2; also elsewhere on the board
/Front PCB/PULSE_OUT: J2.2; also elsewhere on the board
/Front PCB/PWMIN: J1.4; also elsewhere on the board
/Front PCB/SAW_OUT: J2.3; also elsewhere on the board
/Front PCB/SOFT_SYNCA: J6.1; also elsewhere on the board
/Front PCB/SOFT_SYNC_OFF: J7.1; also elsewhere on the board
/Front PCB/SYNC: J1.6; also elsewhere on the board
/Front PCB/SYNCA: J5.1; also elsewhere on the board
/Front PCB/TRIANGLE_OUT: J2.1; also elsewhere on the board
/Front PCB/V_OCT: J1.9; also elsewhere on the board
/Front PCB/V_OCT2: J1.8; also elsewhere on the board
/Jacks, power, etc/CV_IN_J: J9.5; also elsewhere on the board
/Jacks, power, etc/LIN_FM_IN_J: J9.7; also elsewhere on the board
/Jacks, power, etc/PWMIN_J: J9.4; also elsewhere on the board
/Jacks, power, etc/SYNC_J: J9.6; also elsewhere on the board
/Jacks, power, etc/V_OCT2_J: J9.8; also elsewhere on the board
/Jacks, power, etc/V_OCT_J: J9.9; also elsewhere on the board
/LINK_OUT_CV_B: J11.3, J17.7
/LINK_OUT_FM_B: J11.1, J17.3
/LINK_OUT_PW_B: J11.2, J17.5
/Octave and sync switches/HARD_SYNCA_P: J16.1; also elsewhere on the board
/Octave and sync switches/SOFT_SYNCA_P: J14.1; also elsewhere on the board
/Octave and sync switches/SOFT_SYNC_OFF_P: J15.1; also elsewhere on the board
/Octave and sync switches/SYNCA_P: J13.1; also elsewhere on the board
/Outputs and sin/LINK_OUT_SAW: J17.1; also elsewhere on the board
/Outputs and sin/PULSE_OUT_S: J10.2; also elsewhere on the board
/Outputs and sin/SAW_OUT_S: J10.3; also elsewhere on the board
/Outputs and sin/TRIANGLE_OUT_S: J10.1; also elsewhere on the board
GND: J1.1; also elsewhere on the board
GND1: J9.1, J17.2, J17.4, J17.6, J17.8; also elsewhere on the board

Notes on the sheet:
FRONT PCB
PANEL MOUNT
Link header
BACK PCB

Parts:
B1: Board; Board_Marker
C1, C2, C3, C4, C5, C6: 100nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C7, C12: 100nF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C8, C10, C11, C13: 10nF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C9: 1nF; C_Rect_L7.2mm_W4.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
D1, D2: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
GRAF1: Holes; herovco_panel_behind
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3
R1, R18, R19: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 24k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R16: 5.6k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R5, R6, R8, R10, R21, R26, R28: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7: 470k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R12, R22, R27, R31: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11, R15: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R13: 1.8k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R14: 1.5M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R17, R20, R29: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R23, R24: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R25: 240k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R30: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1, RV3, RV4, RV7, RV8: 100k; Potentiometer_Alpha_RD901F-40-00D_Single_Vertical_centered
RV2, RV5, RV6: 10k; Potentiometer_Bourns_3296W_Vertical_screw_centered
RV9: 50k; Potentiometer_Bourns_3296W_Vertical_screw_centered
TP1: +12V; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP2: +5VREF; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP3: -12V; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP4: -5VREF; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP5: GND; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP6: -5V; TestPoint_THTPad_D1.5mm_Drill0.7mm
U1: TL074; DIP-14_W7.62mm_Socket_LongPads
U2: TL072; DIP-8_W7.62mm_Socket_LongPads
U3: AS3340A; DIP-16_W7.62mm_Socket_LongPads
U4, U5: LM4040BIZ-5; TO-92_Inline_Wide
U6: L79L05_TO92; TO-92_Inline_Wide

Connections:
+12V: C2.1, C4.1, C6.1, R14.1, R23.1, R29.2, RV7.3, TP1.1, U1.4 (V+), U2.8 (V+), U3.16 (VCC); also elsewhere on the board
-5V: C1.1, C13.2, D2.1 (K), R3.2, RV2.2, RV2.3, TP6.1, U3.3 (VEE), U6.3 (VO)
-12V: C3.2, C5.2, D2.2 (A), R24.2, RV7.1, TP3.1, U1.11 (V-), U2.4 (V-), U6.2 (VI); also elsewhere on the board
/Front PCB/+5V_REF: R23.2, RV1.3, RV6.3, TP2.1, U4.2 (K); also elsewhere on the board
/Front PCB/-5V_REF: R24.1, RV1.1, TP4.1, U5.3 (A); also elsewhere on the board
/Front PCB/CENTER_FREQ: R20.2, RV6.2
/Front PCB/CV_IN: RV3.3; also elsewhere on the board
/Front PCB/CV_SUM: R12.1, R21.2, U1.8; also elsewhere on the board
/Front PCB/FINE_TUNE: R7.2, RV1.2
/Front PCB/FREQ_CV: R8.2, RV3.2
/Front PCB/HARD_SYNCA: R16.2; also elsewhere on the board
/Front PCB/HI_FREQ_TRACK: R19.2, RV5.2
/Front PCB/LINK_OUT_FM: C10.2, U1.13 (-), U1.14; also elsewhere on the board
/Front PCB/LINK_OUT_PW: R31.1, U2.7; also elsewhere on the board
/Front PCB/LIN_FM_CV: RV4.2, U1.12 (+)
/Front PCB/LIN_FM_IN: RV4.3; also elsewhere on the board
/Front PCB/OCTAVE: U1.3 (+); also elsewhere on the board
/Front PCB/PULSE_OUT: R1.1, U3.4 (Pulse_Output); also elsewhere on the board
/Front PCB/PULSE_WIDTH: R25.2, RV7.2
/Front PCB/PWM: R26.2, RV8.2
/Front PCB/PWMIN: RV8.3; also elsewhere on the board
/Front PCB/SAW_OUT: U3.8 (Saw_Output); also elsewhere on the board
/Front PCB/SOFT_SYNCA: R17.2; also elsewhere on the board
/Front PCB/SOFT_SYNC_OFF: C12.2; also elsewhere on the board
/Front PCB/SYNC: C7.2; also elsewhere on the board
/Front PCB/SYNCA: C7.1; also elsewhere on the board
/Front PCB/TRIANGLE_OUT: U3.10 (Triangle_Output); also elsewhere on the board
/Front PCB/V_OCT: R5.2; also elsewhere on the board
/Front PCB/V_OCT2: R6.2; also elsewhere on the board
CV_NODE: R11.1, R19.1, R20.1, R21.1, U3.15 (Freq_CV)
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, C8.2, C9.1, C11.2, C12.1, C13.1, R13.2, R22.1, RV3.1, RV4.1, RV5.1, RV6.1, RV8.1, RV9.1, TP5.1, U1.5 (+), U1.10 (+), U2.3 (+), U2.5 (+), U3.12 (GND), U4.3 (A), U5.2 (K), U6.1 (GND); also elsewhere on the board
HARD_SYNC: D1.2 (A), U3.6 (Hard_Sync)
HFT: RV5.3, U3.7 (HFT)
LIN_FM: R14.2, R15.1, R18.1, U3.13 (Linear_FM)
unnamed: C8.1, R11.2
unnamed: C9.2, U3.11 (Cap)
unnamed: C10.1, R18.2
unnamed: C11.1, R15.2
unnamed: D1.1 (K), R16.1, R22.2
unnamed: R2.1, U3.1 (Scale1)
unnamed: R2.2, RV2.1
unnamed: R3.1, U3.2 (Scale2)
unnamed: R4.2, U1.1, U1.2 (-)
unnamed: R9.2, R10.1, U1.7
unnamed: R4.1, R5.1, R6.1, R7.1, R8.1, R10.2, U1.6 (-)
unnamed: R9.1, R12.2, U1.9 (-)
unnamed: R13.1, U3.14 (Scale)
unnamed: R25.1, R26.1, R28.2, U2.2 (-)
unnamed: R27.1, R31.2, U2.6 (-)
unnamed: R27.2, R28.1, R30.2, U2.1
unnamed: R29.1, R30.1, RV9.3
PWM_IN: R1.2, RV9.2, U3.5 (PWM_Input)
SOFT_SYNC: R17.1, U3.9 (Soft_Sync)

Notes on the sheet:
3340
±5 V REFERENCES
TRACKING
For VCC=12V, PWM_IN value for 100% PW is typically 4.0 V, maximum 4.3 V. With PWMIN=0, PULSE_WIDTH ±12 V becomes ∓5 V at op amp output. With PULSE_WIDTH=0, PWM_IN ±5 V becomes ∓5 V at op amp output. Either way LINK_OUT_PW becomes ±5 V. (Larger range if both CVs are nonzero.) At top of trimmer V is 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
Use AS3340 or AS3340A. "AS3340A [has] much more output frequency stability against Vcc and VEE ....[and] benefits from improved symmetry of rising and falling edge of triangle signal (approx. 50%)."
-5V REGULATOR
These resistors precision or hand matched
PWM max limit
CONTROL VOLTAGES
Thomas Henry claims 1M between pins 4 and 5 improves pulse wave fall time and 1 nF cap from pin 5 to ground suppresses falling edge oscillations. What I see is 1M suppresses oscillations, does not affect fall time, and 1 nF makes fall time significantly worse. Must be something else going on I gues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
POWER CONNECTIONS
Regulated -5V is recommended by Alfa, and tests show it mostly suppresses PW frequency shift.

Parts:
B3: Board; Board_Marker
R32, R33, R34, R35, R36, R37, R38, R39, R40, R41: 10k 1/8W; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: SW_Rotary12; Rotary_Switch
SW2: SW_DP3T; SW_CK_OS203012MU5QP1_DP3T; Part OS203012MU5QP1‎

Connections:
/Octave and sync switches/HARD_SYNCA_P: SW2.5; also elsewhere on the board
/Octave and sync switches/SOFT_SYNCA_P: SW2.2, SW2.8; also elsewhere on the board
/Octave and sync switches/SOFT_SYNC_OFF_P: SW2.1, SW2.3; also elsewhere on the board
/Octave and sync switches/SYNCA_P: SW2.6; also elsewhere on the board
unnamed: R32.1, R33.2, SW1.10
unnamed: R32.2, SW1.11
unnamed: R33.1, R34.2, SW1.9
unnamed: R34.1, R35.2, SW1.8
unnamed: R35.1, R36.2, SW1.7
unnamed: R36.1, R37.2, SW1.6
unnamed: R37.1, R38.2, SW1.5
unnamed: R38.1, R39.2, SW1.4
unnamed: R39.1, R40.2, SW1.3
unnamed: R40.1, R41.2, SW1.2
unnamed: R41.1, SW1.1

Notes on the sheet:
Panel mounted
SYNC SWITCH
OCTAVE SWITCH
Precision or hand matched resistors

Parts:
C16, C17: 100nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C18, C19: 330pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
Q1, Q2: 2N3904; TO-92_Inline_Wide
R42: 30k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R43, R48: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R44, R46, R62, R63, R64: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R45: 390R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R47, R52, R54, R55: 18k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R49, R50: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R51: 2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R53: 33k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R56, R57, R58: 24k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R59, R60, R61: 9.1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R65, R66, R67: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV10, RV11: 50k; Potentiometer_Bourns_3296W_Vertical_screw_centered
RV12: 5k; Potentiometer_Bourns_3296W_Vertical_screw_centered
U7: TL074; DIP-14_W7.62mm_Socket_LongPads

Connections:
+12V_1: C16.1, R44.1, R46.1, R56.2, R57.2, R58.2, U7.4 (V+); also elsewhere on the board
-12V_1: C17.2, R47.1, U7.11 (V-); also elsewhere on the board
/Jacks, power, etc/SIN: R51.1, RV12.2, RV12.3; also elsewhere on the board
/Outputs and sin/LINK_OUT_SAW: C18.1, R63.1, R66.2, U7.1; also elsewhere on the board
/Outputs and sin/PULSE_OUT_S: R53.2; also elsewhere on the board
/Outputs and sin/SAW_OUT_S: R52.2; also elsewhere on the board
/Outputs and sin/TRIANGLE_OUT_S: U7.10 (+); also elsewhere on the board
GND1: C16.2, C17.1, R43.2, R48.2, R49.2, R54.2, R55.2, R59.2, R60.2, R61.2, RV12.1; also elsewhere on the board
unnamed: C18.2, R57.1, R60.1, R63.2, U7.2 (-)
unnamed: C19.1, R64.1, R67.2, U7.7
unnamed: C19.2, R58.1, R61.1, R64.2, U7.6 (-)
unnamed: Q1.1 (E), R45.2, RV11.1
unnamed: Q1.2 (B), R43.1, RV10.1
unnamed: Q1.3 (C), R44.2, R50.2, U7.13 (-)
unnamed: Q2.1 (E), R45.1, RV11.3
unnamed: Q2.2 (B), R48.1
unnamed: Q2.3 (C), R46.2, R49.1, U7.12 (+)
unnamed: R42.1, RV10.2, RV10.3
unnamed: R47.2, RV11.2
unnamed: R50.1, R51.2, U7.14
unnamed: R52.1, R54.1, U7.3 (+)
unnamed: R53.1, R55.1, U7.5 (+)
unnamed: R56.1, R59.1, R62.2, U7.9 (-)
PULSE: R67.1; also elsewhere on the board
SAW: R66.1; also elsewhere on the board
TRI: R65.1; also elsewhere on the board
TRI_RAW: R42.2, R62.1, R65.2, U7.8

Notes on the sheet:
OUTPUT CONDITIONING
Sine amplitude
Kassutronics used 100k feedback resistors and similarly large values for voltage divider resistors. AS3340 datasheet calls for a 51k pulldown on pin 4, so I reduced the voltage divider resistances by a factor ~ (51k/(180k+100k)). Op amp resistances were reduced by a factor of 10. Then stabilization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
SINE SHAPING
Sine symmetry
Sine round

Parts:
B2: Board; Board_Marker
C14, C15: 10uF; CP_Radial_D6.3mm_P2.50mm
D3, D4: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
GRAF2: Holes; herovco_panel_holes
GRAF3: AO logo; analogoutput
GRAF4: CC0 logo; CC0_logo
H4, H5, H6: MountingHole; MountingHole_3.2mm_M3
J18, J19, J20, J21, J22, J24, J25, J26, J27, J28: AudioJack2; Jack_6.35mm_PJ_629HAN_slots
J23: Synth_power_2x5; Power_Header
TP7: +12V; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP8: -12V; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP9: GND; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm

Connections:
+12V_1: C14.1, D3.1 (K), TP7.1; also elsewhere on the board
-12V_1: C15.2, D4.2 (A), TP8.1; also elsewhere on the board
/Jacks, power, etc/+12V_IN: D3.2 (A), J23.9 (+12V), J23.10 (+12V)
/Jacks, power, etc/-12V_IN: D4.1 (K), J23.1 (-12V), J23.2 (-12V)
/Jacks, power, etc/CV_IN_J: J21.T; also elsewhere on the board
/Jacks, power, etc/LIN_FM_IN_J: J19.T; also elsewhere on the board
/Jacks, power, etc/PWMIN_J: J18.T; also elsewhere on the board
/Jacks, power, etc/SIN: J24.T; also elsewhere on the board
/Jacks, power, etc/SYNC_J: J20.T; also elsewhere on the board
/Jacks, power, etc/V_OCT2_J: J28.T; also elsewhere on the board
/Jacks, power, etc/V_OCT_J: J22.T; also elsewhere on the board
GND1: C14.2, C15.1, J18.S, J19.S, J20.S, J21.S, J22.S, J23.3 (GND), J23.4 (GND), J23.5 (GND), J23.6 (GND), J23.7 (GND), J23.8 (GND), J24.S, J25.S, J26.S, J27.S, J28.S, TP9.1; also elsewhere on the board
PULSE: J26.T; also elsewhere on the board
SAW: J27.T; also elsewhere on the board
TRI: J25.T; also elsewhere on the board

Notes on the sheet:
POWER
JACKS

Board: 2 copper layers, 269.0 x 172.0 mm, 151 parts (96 on the bottom side), 95 nets.
